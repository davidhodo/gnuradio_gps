<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>31</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_l2</value></param>
<param><key>value</key><value>1.22760e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_off</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_l1</value></param>
<param><key>value</key><value>1.57542e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/is4s/devel/gnuradio_gps/usrp_l1.dat</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/is4s/devel/gnuradio_gps/usrp_l2.dat</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>otw</key><value>sc8</value></param>
<param><key>stream_args</key><value>peak=0.01</value></param>
<param><key>dev_addr</key><value>addr0=192.168.10.3,addr1=192.168.10.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq_l1, lo_off)</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq1</key><value>uhd.tune_request(freq_l2, lo_off)</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
